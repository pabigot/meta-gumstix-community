SRCREV_overo = "04b1732220078d47c18a84cbafc52e45db71f13d"
PV_overo = "1.5.0+git${SRCREV}"

